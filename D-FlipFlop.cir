[aimspice]
[description]
230
D-Flip Flop 1
.include NAND_GATE.cir
.include inverter.cir

vdd1 VDD GND dc 1

XINV1  VDD GND INP 2 invert
XNAND1 VDD GND INP CLK 1 NAND
XNAND2 VDD GND 2 CLK 3 NAND
XNAND3 VDD GND 1 5 4 NAND
XNAND4 VDD GND 3 4 5 NAND

[end]
